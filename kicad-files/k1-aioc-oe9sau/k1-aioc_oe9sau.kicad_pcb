# Repository OE9SAU/AIOC

File README.md:

# PCB V1.2: Revised the PCB design for my component availability

# AIOC
This is the Ham Radio *All-in-one-Cable*. by skuep. https://github.com/skuep/AIOC
See github for all other informations!

## KiCad design kicad-files/k1-aioc-oe9sau/k1-aioc_oe9sau.kicad_pcb

Board: 2 copper layers, 21.0 x 31.5 mm, 42 parts (2 on the bottom side), 31 nets.

Parts:
C1, C2: 10pF/NP0; C_0603_1608Metric
C5, C6, C7, C10, C13, C14: 3,3µF/10V/X5R; C_0603_1608Metric
C8, C9, C12, C15: 100n; C_0603_1608Metric
C11: 10n/NP0; C_0603_1608Metric
D1: GREEN; LED_0603_1608Metric
D2: RED; LED_0603_1608Metric
D3, D4: N.M.; LED_0603_1608Metric
FB1, FB2: 600R@100MHz; L_0603_1608Metric
H1, H2: ToolingHole; TOOLING-HOLE
J1: 12401832E402A; USB_Mini-B_Wuerth_65100516121_Horizontal
J2: Conn_01x07_Male; PinHeader_1x07_P1.27mm_Vertical
Q1: BC847BS; SOT-363_SC-70-6
R1: 1.5K; R_0603_1608Metric
R2: 10K; R_0603_1608Metric
R3, R16: 5.1K; R_0603_1608Metric
R4, R8, R9, R15: 220R; R_0603_1608Metric
R5, R10, R11, R14: 2.2K; R_0603_1608Metric
R12, R13: 22R; R_0603_1608Metric
R17: N.M.; R_0603_1608Metric
U1: TS78L03CX; SOT-23-3
U2: STM32F302CBT6; LQFP-48_7x7mm_P0.5mm
Y1: XTAL_ABM3B-8.000MHZ-10-D1G-T

Connections:
+3V3: C7.1, C8.1, C9.1, C10.1, FB1.1, J2.7, R1.1, R16.1, U2.1 (VBAT), U2.9 (VDDA), U2.17 (VDD), U2.24 (VDDSD), U2.25 (VREFSD+), U2.36 (PF7), U2.48 (VDD)
/AFIN: C11.1, R3.2, R5.1, R16.2, U2.20 (PB2)
/AFOUT: R2.2, U2.14 (PA4)
/BOOT0: J2.1, R14.2, U2.44 (BOOT0)
/DAC_ATTEN: R17.2, U2.13 (PA3)
/NRST: C15.1, J2.3, U2.7 (NRST)
/OSCIN: C1.1, U2.5 (PF0), Y1.1
/OSCOUT: C2.2, U2.6 (PF1), Y1.3
/PTT1: R11.1, U2.11 (PA1)
/PTT2: R10.1, U2.10 (PA0)
/RADIO-RX-PTT1: R8.1, R13.1
/SWCLK: J2.6, U2.37 (PA14)
/SWDIO: J2.4, U2.34 (PA13)
/SWO: J2.2, U2.39 (PB3)
/USART-RX: R9.2, U2.31 (PA10)
/USART-TX: R8.2, U2.30 (PA9)
/USB-DN: J1.2, U2.32 (PA11)
/USB-DP: J1.3, R1.2, U2.33 (PA12)
/VBUS: FB2.2, J1.1
/VIN: C6.1, FB2.1, U1.2
GND: C1.2, C2.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, J1.5, J1.6, J2.5, Q1.1 (E1), Q1.4 (E2), R3.1, R4.1, R14.1, U1.3, U2.8 (VSSA), U2.23 (VSSSD), U2.35 (PF6), U2.47 (VSS), Y1.2, Y1.4
unnamed: C12.1, C13.1, R2.1, R4.2, R17.1
unnamed: C14.1, R5.2
unnamed: D1.1 (K), D2.2 (A), D3.1 (K), D4.2 (A), R15.1
unnamed: D1.2 (A), D2.1 (K), D3.2 (A), D4.1 (K), U2.46 (PB9)
unnamed: Q1.2 (B1), R10.2
unnamed: Q1.3 (C2), R13.2
unnamed: Q1.5 (B2), R11.2
unnamed: Q1.6 (C1), R12.2
unnamed: R15.2, U2.45 (PB8)
VOUT: C5.1, FB1.2, U1.1

## Commit log

2024-02-23 Create Version USB-B Mini
2024-02-23 Add files via upload
    Crystal update
2024-02-26 Create g
